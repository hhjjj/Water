# Repository hhjjj/Water

## EAGLE design RobotFish.brd

Parts:
C1, C2: 0.1uF; C0603(1608)
C3, C4: 10uF, 16V; C1206(3216)-A
CN1: JST_2PIN-THM-RA; JST-PH-2-THM-RA
D1, D2, D3: MBR120; SOD-123
JP1: M05PTH; 1X05
LED1, LED2: LED0603; LED-0603
LED3: LED3MM
R1, R8, R9, R14: 100k; R0603(1608)
R2: 1M; R0603(1608)
R3, R4, R10: 4.7k; R0603(1608)
R5, R11, R13: 10k; R0603(1608)
R6, R7, R12: 1k; R0603(1608)
TP1, TP2, TP3, TP4: TP-5010
TR1: SSM3J338R; SOT23
TVS1: SD05C; SOD-323-NOPOL
U1: 16F1575; SO-14
U2: MCP73831/OT; SOT23-5L
U3: MCP1754S_SOT23; SOT23
X1: JST_3PIN; SM03B-SRSS-TB

Connections:
+3.3V: C2.1, C4.1 (+), JP1.2, R1.2, U1.1 (VDD), U3.2
+5V: D1.C, D2.A, LED2.A, R2.2, TVS1.2, U2.4 (VDD)
BAT_ADC: R8.1, R9.2, U1.3 (RA4)
DGND: C1.2, C2.2, C3.2 (-), C4.2 (-), CN1.2 (1), JP1.3, LED1.C, LED3.K (C), R2.1, R5.1, R9.1, R13.1, TP2.TP, TVS1.1, U1.14 (VSS), U2.2 (VSS), U3.1, X1.1
ICSPCLK: JP1.5, U1.12 (RA1)
ICSPDAT: JP1.4, U1.13 (RA0)
LED_STAT: R6.1, U1.7 (RC3)
unnamed: R5.2, U2.5 (PROG)
unnamed: R7.2, U2.1 (STAT)
unnamed: LED2.C, R7.1
unnamed: R10.2, U1.8 (RC2)
unnamed: D1.A, TP1.TP
unnamed: R3.1, U1.5 (RC5)
unnamed: R4.1, U1.6 (RC4)
unnamed: LED1.A, LED3.A, R6.2
unnamed: R11.2, TP3.TP
unnamed: R12.2, TP4.TP
RESET: C1.1, JP1.1, R1.1, U1.4 (/MCLR)
RX: R3.2
SERVO_ON: R14.1, TR1.1 (G), U1.9 (RC1)
SERVO_POWER: TR1.3 (D), X1.2
SERVO_PWM: R10.1, X1.3
TX: R4.2
VBAT: CN1.1 (2), D3.A, R8.2, R14.2, TR1.2 (S), U2.3 (VBAT)
VIN: C3.1 (+), D2.C, D3.C, U3.3
W_IN: R12.1, R13.2, U1.10 (RC0)
W_OUT: R11.1, U1.11 (RA2)

Notes on the sheet:
10k: 100mA
open drain out
로봇 물고기
conductivity measure point
32 gauge (0.2mm) nichromewire

Board: 2 copper layers, 94.0 x 34.2 mm, 36 parts (0 on the bottom side), 25 nets.

## Commit log

2016-10-26 :circus_tent: Added .gitattributes
2016-10-26 sch brd
2016-10-27 schematics
2016-10-28 almost done
2016-10-29 gerber done
2016-11-20 value changed

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
